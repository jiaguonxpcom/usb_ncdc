# IAR project dev_composite_cdc_vcom_cdc_vcom_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MIMXRT1062DVL6A; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/utilities/io; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../devices/MIMXRT1062/utilities/log; ../../../../../../devices/MIMXRT1062/utilities; ../../../../../../devices/MIMXRT1062/xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: dev_composite_cdc_vcom_cdc_vcom_bm.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SDRAM_IS_SHAREABLE; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1062DVL6A; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MIMXRT1062DVL6A; USB_STACK_BM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SDRAM_IS_SHAREABLE; NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1062DVL6A; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group board/src
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group sources
    ../: composite.c composite.h usb_composite_config.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h
  group startup
    ../../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../../../../../../devices/MIMXRT1062/: system_MIMXRT1062.c system_MIMXRT1062.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb/include/: usb_ehci.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1062/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MIMXRT1062/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../../devices/MIMXRT1062/xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
